# Keil uVision project sky_star_protocol_node.uvprojx, settings and files
target sky_star_protocol_node (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: sky_star_protocol_node +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../../Core/Inc;../../Drivers/STM32F4xx_HAL_Driver/Inc;../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../Drivers/CMSIS/Include;../../../common/include;../../../hal/include;../../../app/include
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/MemberC
    ../../../common/src/: mc_protocol_runner.c mc_cli_rx.c mc_truth_log.c mc_faults.c
    ../../../hal/src/: mc_stm32f407_hal_port.c
    ../../../app/src/: mc_board_app.c mc_oled.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../../Core/Src/: system_stm32f4xx.c
